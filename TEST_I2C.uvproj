# Keil uVision project TEST_I2C.uvproj, settings and files
target TEST_I2C (MCS-51)
  device: AT89F52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: TEST_I2C +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: TFT_CFG=TFT_AT070TN94,PLATFORM_CFG=PLATFORM_VID1319_101_128,USE_CFG=USE_FLASH
  group BIT1618C_VID1319_101_128_FLASH
    ./: BITEK.C COMMON.C DISPATCH.C FLASH.c GPI.C I2C.C MAIN.C MCU.C OSD.C PLATFORM.C POR.C SPI.C TIMER.C VP.C
